# IAR project I2C_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x6 ST STM32L152x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: .\inc; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Test.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: Buffer.c Buffer.h I2C.c I2C.h I2C_Buffer.c I2C_Buffer.h I2C_Device.c I2C_Device.h I2C_Operation.c I2C_Operation.h Interrupt.c Interrupt.h main.c MS5611.c MS5611.h
  group src/CMSIS
    src/CMSIS/: core_cm3.c system_stm32l1xx.c
  group src/inc
    src/inc/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32l1xx.h stm32l1xx_conf.h system_stm32l1xx.h
  group src/startup
    src/startup/: startup_stm32l1xx_md.s
