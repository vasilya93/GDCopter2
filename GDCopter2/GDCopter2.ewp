# IAR project GDCopter2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_FULL_ASSERT
  ICCARM.CCIncludePath2: .\include; ..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: devInfo.txt
  group source
    source/: main.c
  group source/CMSIS
    source/CMSIS/: core_cm3.c system_stm32l1xx.c
  group source/include
    source/include/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32l1xx.h stm32l1xx_conf.h system_stm32l1xx.h
  group source/myLib
    source/myLib/: USART.c USART.h
  group source/startup
    source/startup/: startup_stm32l1xx_md.s
